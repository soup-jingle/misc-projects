## c/kernel(lotterysched)/linux-2.6/kernel/sched/Kconfig
```kconfig
## ADD LOTTO SCHEDULER; PB ##
config SCHED_LOTTO
       bool "Use Lottery Scheduler"
       default y
```
